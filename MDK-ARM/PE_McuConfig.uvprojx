# Keil uVision project PE_McuConfig.uvprojx, settings and files
target PE_McuConfig_CM4 (ARM-ADS)
  device: STM32H745BITx:CM4 STMicroelectronics
  cpu: IRAM(0x10000000-0x10047FFF) IRAM2(0x18000000-0x1800FFFF) IROM(0x8100000-0x81FFFFF) CLOCK(12000000) FPU3(SFPU) CPUTYPE("Cortex-M4") TZ
  output: PE_McuConfig_CM4 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: CORE_CM4,USE_HAL_DRIVER,STM32H745xx
  c include: ../CM4/Core/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8100000 size 0x100000
  memory RVCT9: RAM 0x10000000 size 0x48000
  memory RVCT10: RAM 0x18000000 size 0x10000
  scatter file: stm32h745xx_flash_CM4.sct
  group Application/MDK-ARM
    ./: startup_stm32h745xx_CM7.s startup_stm32h745xx_CM4.s
  group Application/User/CM4/Core
    ../CM4/Core/Src/: main.c stm32h7xx_it.c stm32h7xx_hal_msp.c
  group Application/User/CM7/Core
    ../CM7/Core/Src/: main.c stm32h7xx_it.c stm32h7xx_hal_msp.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_comp.c stm32h7xx_hal_dfsdm.c stm32h7xx_hal_eth.c stm32h7xx_hal_eth_ex.c stm32h7xx_hal_fdcan.c stm32h7xx_hal_hrtim.c stm32h7xx_hal_smbus.c stm32h7xx_hal_lptim.c stm32h7xx_hal_ltdc.c stm32h7xx_hal_ltdc_ex.c stm32h7xx_ll_sdmmc.c stm32h7xx_ll_delayblock.c stm32h7xx_hal_sd.c stm32h7xx_hal_sd_ex.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_pcd.c stm32h7xx_hal_pcd_ex.c stm32h7xx_ll_usb.c
  group Drivers/CMSIS
    ../Common/Src/: system_stm32h7xx_dualcore_boot_cm4_cm7.c
target PE_McuConfig_CM7 (ARM-ADS)
  device: STM32H745BITx:CM7 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.7.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x00000000-0xFFFF) IROM(0x8000000-0x80FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: PE_McuConfig_CM7
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: CORE_CM7,USE_HAL_DRIVER,STM32H745xx
  c include: ../CM7/Core/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x0 size 0x10000
  scatter file: stm32h745xx_flash_CM7.sct
software components: CMSIS:CORE 4.3.0
